# Keil uVision project STM32F4_RTT2.0_Example.uvproj, settings and files
target example (ARM-ADS)
  device: STM32F405RG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: STM32F4_RTT2.0_Example
  c flags: Optim=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\Applications;..\Drivers;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\RT-Thead\finsh;..\RT-Thead\include;..\RT-Thead\Kernel;..\Libraries\CMSIS\ST\STM32F4xx\Include;..\Modules;..\Modules\attitude_estimator_ekf
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Applications
    ../Applications/: startup.c app_led.c app_sensors.c app_att_est_ekf.c
  group Drivers
    ../Drivers/: board.c stm32f4xx_it.c serial.c led.c spi.c mpu9250.c hrt.c
  group Libraries
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
    ../Libraries/CMSIS/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Cortex-m4
    ../Cortex-M4/: backtrace.c cpuport.c div0.c showmem.c context_rvds.S
    ../Libraries/CMSIS/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
  group RT-Thread/kernel
    ../RT-Thead/Kernel/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c module.c object.c scheduler.c slab.c thread.c timer.c
  group RT-Thread/finsh
    ../RT-Thead/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c msh.c msh_cmd.c shell.c symbol.c
  group Modules
    ../Modules/: uorb.c kalmanfilter.c
  group Attitude_estimator_ekf
    ../Modules/attitude_estimator_ekf/: attitudeKalmanfilter.c attitudeKalmanfilter_initialize.c attitudeKalmanfilter_terminate.c cross.c eye.c mrdivide.c norm.c rdivide.c rt_nonfinite.c rtGetInf.c rtGetNaN.c
